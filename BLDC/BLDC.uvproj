# Keil uVision project BLDC.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: BLDC +hex
  group Source Group 1
    ./: main.c FOC_Controller.c FOC_Controller.h PWM_Controller.c PWM_Controller.h
