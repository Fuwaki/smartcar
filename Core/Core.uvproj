# Keil uVision project Core.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: Core +hex
  group Source Group 1
    ./: main.c uart.c uart.h AR_PF.c AR_PF.h Muti_SPI_Device.c Muti_SPI_Device.h
