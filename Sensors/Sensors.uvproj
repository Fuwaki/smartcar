# Keil uVision project Sensors.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: Sensors +hex
  group Source Group 1
    ./: main.c GPS.c GPS.h SPI_MultiDevice.c SPI_MultiDevice.h Encoder.c Encoder.h Timer.c Timer.h uart.c uart.h Fusion.c Fusion.h GPS_uart.c GPS_uart.h Gyroscope.c Gyroscope.h Magnetic.c Magnetic.h
